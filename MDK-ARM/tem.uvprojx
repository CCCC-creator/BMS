# Keil uVision project tem.uvprojx, settings and files
target tem (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: tem +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../Bsp;../Middleware/FreeRTOS/include;../Middleware/FreeRTOS/portable/RVDS/ARM_CM3;../Middleware/CANopen/CANopenNode;../Middleware/CANopen/CANopenNode/301;../Middleware/CANopen/CANopenNode/303;../Middleware/CANopen/CANopenNode/304;../Middleware/CANopen/CANopenNode/305;../Middleware/CANopen/CANopenNode/309;../Middleware/CANopen/CANopenNode/storage;../Middleware/CANopen/CANopenNode/extra;../Middleware/CANopen/Driver_STM32;../Middleware/CANopen/OD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c iwdg.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group APP
    ../App/: app_task.c app_init.c Canopen_app.c
  group BSP
    ../Bsp/: bq76940.c faultcheck.c faulthandling.c monitor.c soc.c balancing.c
  group Middlewares/CANopen_OD
    ../Middleware/CANopen/OD/: OD.c
  group Middlewares/CANopenNode
    ../Middleware/CANopen/CANopenNode/: CANopen.c
  group Middlewares/CANopenNode/301
    ../Middleware/CANopen/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
  group Middlewares/CANopenNode/EXT
    ../Middleware/CANopen/CANopenNode/303/: CO_LEDs.c
    ../Middleware/CANopen/CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ../Middleware/CANopen/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ../Middleware/CANopen/CANopenNode/309/: CO_gateway_ascii.c
    ../Middleware/CANopen/CANopenNode/extra/: CO_trace.c
  group Middlewares/CANopenNode/STORAGE
    ../Middleware/CANopen/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
  group Middlewares/CANopen_Port
    ../Middleware/CANopen/Driver_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c
  group Middlewares/FreeRTOS_CORE
    ../Middleware/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middleware/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 4.3.0
